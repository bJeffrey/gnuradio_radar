options:
  parameters:
    generate_options: qt_gui
    id: radar
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '2.0'
  states: {}
- name: bandwidth_khz
  id: variable
  parameters:
    value: time_bandwidth_product / tau_sec / 1e3
  states: {}
- name: bandwidth_khz_lower_limit
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: bandwidth_khz_upper_limit
  id: variable
  parameters:
    value: '6000.0'
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: distance_to_target_m
  id: variable
  parameters:
    value: max_unambiguous_range_m / 0.5
  states: {}
- name: duty_cycle
  id: variable
  parameters:
    value: '0.06'
  states: {}
- name: fc_Hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,0,1,1
    label: Center Frequencies (Hz)
    type: raw
    value: '[5e3,10e3,15e3]'
  states: {state: disabled}
- name: lambda_m
  id: variable
  parameters:
    value: c / pulse_center_freq_hz
  states: {}
- name: max_unambiguous_range_m
  id: variable
  parameters:
    value: c * pri_sec
  states: {}
- name: max_unambiguous_vel_mps
  id: variable
  parameters:
    value: prf_khz  * 1.0e3 * lambda_m / 4.0
  states: {}
- name: num_pulses_per_cpi
  id: variable
  parameters:
    value: '18'
  states: {}
- name: num_samples_during_pulse_silence
  id: variable
  parameters:
    value: num_samples_per_pulse - num_samples_during_pulse_tx
  states: {}
- name: num_samples_during_pulse_tx
  id: variable
  parameters:
    value: int(num_samples_per_pulse * duty_cycle)
  states: {}
- name: num_samples_per_pulse
  id: variable
  parameters:
    value: int(float(samp_rate) / (float(prf_khz) * 1e3))
  states: {}
- name: prf_khz
  id: variable
  parameters:
    value: '3.90625'
  states: {}
- name: pri_sec
  id: variable
  parameters:
    value: 1/(prf_khz * 1e3)
  states: {}
- name: pulse_center_freq_hz
  id: variable
  parameters:
    value: 10.0e3
  states: {}
- name: range_to_target
  id: variable
  parameters:
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: target_vel_mps
  id: variable
  parameters:
    value: max_unambiguous_vel_mps / 2
  states: {}
- name: tau_sec
  id: variable
  parameters:
    value: pri_sec * duty_cycle
  states: {}
- name: time_bandwidth_product
  id: variable
  parameters:
    value: '10.0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: prf_khz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(range_to_target / (3e8) * samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samples_per_pulse
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_samples_per_pulse*num_pulses_per_cpi
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: num_samples_per_pulse
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: signalSource.generate_lfm_pulse(prf_khz, duty_cycle, amplitude, time_bandwidth_product, pulse_center_freq_hz, bandwidth_khz_lower_limit, bandwidth_khz_upper_limit, bandwidth_khz, num_samples_per_pulse, samp_rate)
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_samples_per_pulse
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_samples_per_pulse*num_pulses_per_cpi
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    # time-bandwidth product should be [75, 10,000] for LFM system\n    def __init__(\n        self,\n        prf_khz=3,\n        pri_sec=0.001,\n        duty_cycle=0.06,\n        tau_sec=0.01,\n        time_bandwidth_product=100,\n        pulse_center_freq_hz=500,\n        bandwidth_khz_lower_limit=1,\n        bandwidth_khz_upper_limit=100,\n        bandwidth_khz=50,\n        num_samples_per_pulse=128,\n        num_pulses_per_cpi=18,\n        num_samples_during_pulse_tx=100,\n        num_samples_during_pulse_silence=122,\n        samp_rate=100e3,\n        t=np.linspace(0, 0.01 , num=100, endpoint=False),\n        amplitude=1.0,\n        phase_ramp=1.0\n    ):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        \"\"\"out_sig=[(np.complex64,1024), (np.uint16, 1)]\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Linear Frequency Modulation',   # will show up in GRC\n            in_sig=[],\n            out_sig=[(np.complex64,1024)]\n        )\n        # log levels: \n        #   trace:      Developing an algorithm and need to log specific values that it calculates\n        #   debug:      Used for debugging purposes, and should not be visible under usual usage\n        #   info:       Information that does not require immediate attention, but might be of interest\n        #   warn:       Something might be wrong and it's probably worth looking into it\n        #   error:      An error has occurred. Meaning something definitely is wrong\n        #   critical:   An error that cannot be recovered from\n        \n        self.log = gr.logger(self.alias()) # initialize logger\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \n        # (max_unambiguous_range = c / (2 * prf) - at 30 kHz, unambiguous to 5000 m, 3.1 mi)\n        #self.prf_khz = prf_khz # pulse repetition frequency\n        #self.pri_sec = pri_sec # pulse repetition interval - time per pulse\n        #self.duty_cycle = duty_cycle # amount of time spent transmitting within a single pri\n        #self.time_bandwidth_product = time_bandwidth_product # tau_sec * bandwidth_khz * 1e3\n        self.pulse_center_freq_hz=pulse_center_freq_hz #center freq of the linearly-modulated pulse\n\n        self.tau_sec = tau_sec # pulse duration\n\n        # calculate bandwidth using TBP and Tau. Check resulting BW to ensure it's reasonable\n        self.bandwidth_khz = bandwidth_khz\n        #self.samp_rate = samp_rate # rate (Hz) the signal is sampled\n        self.num_samples_per_pulse = num_samples_per_pulse\n\n        self.num_pulses_per_cpi = num_pulses_per_cpi\n\n        self.num_samples_during_pulse_tx = num_samples_during_pulse_tx\n\n        #self.num_samples_during_pulse_silence = num_samples_during_pulse_silence\n        \n        self.amplitude = amplitude\n\n        if self.bandwidth_khz > bandwidth_khz_lower_limit or self.bandwidth_khz < bandwidth_khz_upper_limit:\n            self.log.error(f\"Selected bandwidth: {self.bandwidth_khz} kHz out of range\")\n\n        # create the LFM pulse. Note that this is NOT a mathematical addition of two vectors, but a pythonic contatenation\n        self.t = np.linspace(0, tau_sec, num=num_samples_during_pulse_tx, endpoint=False)\n\n        self.lfm_waveform = np.zeros(num_samples_per_pulse, dtype=np.complex64)\n        #self.lfm_waveform[0:self.num_samples_during_pulse_tx] = np.complex64(self.amplitude * np.exp(1j * np.pi * self.bandwidth_khz * 1e3 / self.tau_sec * self.t))\n        \n        self.phase_ramp = np.pi * (bandwidth_khz * 1e3) / self.tau_sec * np.square(self.t)\n        self.lfm_waveform[0:self.num_samples_during_pulse_tx] = self.amplitude * np.cos(2 * np.pi * self.pulse_center_freq_hz * self.t + self.phase_ramp)\n        \n        self.work_counter = 1 # keep track of number of times work is called\n        '''\n        self.log.error(f\"t[10]: {self.t[10]}\")\n        self.log.error(f\"tau_sec: {self.tau_sec}\")\n        self.log.error(f\"bandwidth_khz: {self.bandwidth_khz}\")\n        self.log.error(f\"phase_ramp[10]: {self.phase_ramp[10]}\")\n        self.log.error(f\"pulse_center_freq_hz: {self.pulse_center_freq_hz}\")\n        self.log.error(f\"lfm_waveform[10]: {self.lfm_waveform[10]}\")\n        '''\n    \n    '''\n    Function:    work\n    Description: Takes inputted in-phase (I) and quadrature (Q) channels \n                 and performs linear frequency modulation (i.e., the first step in pulse compression).\n                 Refer to p. 790 (baseband compression only, no regard to starting frequency)\n    '''\n    def work(self, input_items, output_items):\n    \n        #self.log.error(f\"before assignment, output_items[0] length: {len(output_items[0])}\") \n        #output_items[0][:] = np.ones(self.num_samples_per_pulse, dtype=np.complex64) + 5j\n        output_items[0][:] = self.lfm_waveform\n        #self.log.error(f\"lfm_waveform length: {len(self.lfm_waveform)}\")\n        #self.log.error(f\"output_items[0] length: {len(output_items[0])}\")\n        #self.log.error(f\"output_items shape: {np.shape(output_items)}\")\n        #self.log.error(f\"fifth element: {output_items[0][5]}\")\n        #self.log.info(f\"work_counter: {self.work_counter}\")\n        \n        self.work_counter += 1\n        return len(output_items[0])\n\n\n"
    amplitude: amplitude
    bandwidth_khz: bandwidth_khz
    bandwidth_khz_lower_limit: bandwidth_khz_lower_limit
    bandwidth_khz_upper_limit: bandwidth_khz_upper_limit
    duty_cycle: None
    num_pulses_per_cpi: num_pulses_per_cpi
    num_samples_during_pulse_silence: None
    num_samples_during_pulse_tx: num_samples_during_pulse_tx
    num_samples_per_pulse: num_samples_per_pulse
    phase_ramp: None
    prf_khz: None
    pri_sec: None
    pulse_center_freq_hz: pulse_center_freq_hz
    samp_rate: None
    t: None
    tau_sec: tau_sec
    time_bandwidth_product: None
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=4.0e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Matched Filter',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.log = gr.logger(self.alias()) # initialize logger
              self.samp_rate = samp_rate

          def work(self, input_items, output_items):
              received_pulse = input_items[0]
              
              t = np.linspace(0, self.samp_rate*len(received_pulse), num=len(signal), endpoint=False, dtype=complex)
              reference_signal = np.sin(t) # temporarily substitute simple sin wave instead of matched filter
              matched_filter_response = np.conv(reference_signal, received_signal)
              
              output_items[0] = matched_filter_response
              
              """example: multiply with constant"""
              #output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self,\n        num_samples_per_pulse=1024,\n        num_pulses_per_cpi=18,\n        c=3.00e8,\n        distance_to_target_m=100.0 * 1.0e3,\n        target_vel_mps=100.0 * 1.0e3,\n        lambda_m=2,\n        pri_sec=1.0/3.0e3,\n        samp_rate=4e6\n    ):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Target Injection',\n            in_sig=[(np.complex64,1024)], # single pulse\n            out_sig=[(np.complex64,1024*18)] # 1 CPI worth of data\n        )\n        \n        self.log = gr.logger(self.alias())\n        \n        # set CPI parameters\n        self.num_samples_per_pulse = num_samples_per_pulse\n        self.num_pulses_per_cpi = num_pulses_per_cpi\n        self.pulses = np.zeros((self.num_samples_per_pulse, self.num_pulses_per_cpi), dtype=np.complex64)\n        self.pulse_idx = 0\n                \n        # set target parameters\n        self.c = c\n        self.distance_to_target_m = distance_to_target_m        \n        self.target_vel_mps = target_vel_mps\n        self.lambda_m = lambda_m\n        self.pri_sec = pri_sec\n        self.samp_rate = samp_rate\n        # calculate range bin and doppler shift of target\n        self.num_samples_to_target = self.distance_to_target_m * self.samp_rate / self.c\n\n        self.doppler_shift_hz = 2 * self.target_vel_mps / self.lambda_m\n\n        self.log.info(f\"pulses shape: {self.pulses.shape}\")\n\n    def work(self, input_items, output_items):\n        #self.log.info(f\"length of vector: {len(input_items[0][:])}\")\n        #self.log.info(f\"last: {input_items[0][1024*18]}\")\n        \n        #my_temp_1 = self.pulses[:,self.pulse_idx]\n        #self.log.info(f\"my_temp_1.shape: {my_temp_1.shape})\") # ((1024,))\n        \n        #my_temp_2 = self.pulses[self.pulse_idx,:]\n        #self.log.info(f\"my_temp_2.shape: {my_temp_2.shape}\") # (18,)\n        \n        #my_temp_3 = self.pulses\n        #self.log.info(f\"my_temp_3.shape: {my_temp_3.shape}\") # (1024,18)\n        \n        \n        #self.log.error(f\"call {self.pulse_idx} input_items shape: {np.shape(input_items)}\") #(1, 2, 1024)\n        #self.log.info(f\"array_equal: {np.array_equal(input_items[0][0], input_items[0][1])}\")\n        \n        #self.log.info(f\"input_items[0][0][2]: {input_items[0][0][2]}\")\n        #self.log.info(f\"input_items[0][1][3]: {input_items[0][1][3]}\")\n        last_idx = len(input_items[0][:])\n        for i in range (0, last_idx):\n            self.pulses[:,self.pulse_idx] = input_items[0][0][:] # need to loop through this, because I'm getting an input_item that is too large\n            self.pulse_idx += 1\n        \n        # check against pulse_idx+1 due to use of the 0 index\n        if self.pulse_idx+1 < self.num_pulses_per_cpi:\n            #self.log.info(f\"output_items[0]: {len(output_items[0])}\")\n            output_items[0][:] = np.zeros(self.num_samples_per_pulse * self.num_pulses_per_cpi, dtype=np.complex64)\n            #self.log.error(f\"output_items[0] length: {len(output_items[0][:])}\")\n            return len(output_items[0])\n\n        self.log.info(f\"I made it! self.pulses.shape: {self.pulses.shape}\")            \n        # if we made it to this line, it is assumed that we have a full CPI of data.\n\n        all_pulses = self.pulses.flatten()\n        self.log.info(f\"all_pulses length: {len(all_pulses)}\")\n        output_items[0][:] = self.pulses.flatten()\n        \n        self.pulse_idx = 0 # reset the pulse_idx\n        return len(output_items[0])\n\n\n\n\n\n\n\n\n"
    c: c
    distance_to_target_m: distance_to_target_m
    lambda_m: lambda_m
    num_pulses_per_cpi: num_pulses_per_cpi
    num_samples_per_pulse: num_samples_per_pulse
    pri_sec: pri_sec
    samp_rate: samp_rate
    target_vel_mps: target_vel_mps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import signalSource
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: prf_khz * 1e3
    fftsize: '2048'
    name: '"LFM Pulse"'
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: prf_khz * 1e3
    fftsize: '2048'
    name: '"Sine Wave"'
    plotwaterfall: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: prf_khz * 1e3
    fftsize: '2048'
    name: '"Single LFM Pulse"'
    plotwaterfall: 'False'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_head_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_3, '0']
- [blocks_throttle_0, '0', epy_block_3, '0']
- [blocks_throttle_0_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_head_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0_0, '0']
- [epy_block_1, '0', blocks_throttle_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_0_0, '0']
- [epy_block_3, '0', blocks_vector_to_stream_0_0_0, '0']

metadata:
  file_format: 1
